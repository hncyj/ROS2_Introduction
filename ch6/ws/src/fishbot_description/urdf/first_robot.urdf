Commit message: 2025/03/24 revised size error of imu.

File: ch6/ws/src/fishbot_description/urdf/first_robot.urdf (robot description, URDF)
Before this commit: robot first_robot, 2 links, 1 joints
Joints:
- joint imu_joint: origin xyz=0.0 0.0 0.3 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.03 rpy=0.0 0.0 0.0
